# Repository MedadRufus/MastersProject

File README.md:

# MastersProject
 
# Requirements
Design a data logger for E bikes that can record:

It needs to 
* measure: battery current for output and charging(1mA precision), voltage(10mV precision), inclination of road, humidity(as proxy for rain), tempreature of battery, external temperature, e-bike velocity, accleration.
* run off the battery pack
* consume minimal power
* be sturdy enough to survive near the battery pack
* Measure the environmental values(temperature, humidity) without being affected by the system(e.g. heat from the battery)
* measure at least 2 weeks of non stop data
* option to auto upload to the cloud, when connected to wifi.
* cloud dashboard
* log data at max data rate of 1 sample per second
* Needs to handle significant noise in power supply generated by Motor
* Need to handle inductive currents from motor
* Needs isolation from motor.

The idea is to see how estimate battery discharge profiles to do accurate range and state of charge estimations.

Hardware ideas:
* Accleration/tilt from LSM9DS1. Tilt can be measured from sensor fusino on the mcu
* Processor: ESP32
* Current sensor: INA226, 500 kHz +/- 30% sample rate. Up to 36V.
* GPS: Ublox with antenna

# Overall System diagram

# Basic physical design

# Uses of sensor variables

# Software development

The following commands must be run as workarounds on the eBike Blackbox.

## How to disable strapping pin function of the MTDI pin(IO12)

On the PCB, the MTDI pin, IO12, is connected to the SD card MISO pin. In order to boot up, IO12 must be held low. Otherwise, it will brownout. 

Some explanation can be found on the [documentation](https://github.com/espressif/esptool/wiki/ESP32-Boot-Mode-Selection#other-pins).
```
If driven High, flash voltage (VDD_SDIO) is 1.8V not default 3.3V. Has internal pull-down, so unconnected = Low = 3.3V. May prevent flashing and/or booting if 3.3V flash is used and this pin is pulled high, causing the flash to brownout. See the ESP32 datasheet for more details.
```

Unfortunately, when SD card is inserted, MISO pin gets pulled up, causing continuous resets(boot loop).

So to disable this strapping function, we need to set the efuses to disable its functionality. 

So we need to install esptool. On windows 10, using conda terminal, run:
```bash
pip install esptool
```
Then run the following command to actually set the fuses. Set the `-p` argument to the port your esp32 is connected to.
```bash
python -m espefuse set_flash_voltage 3.3V -p COM6
```

You should be done now!

References:  
[https://www.esp32.com/viewtopic.php?t=5970](https://www.esp32.com/viewtopic.php?t=5970)  
[https://forum.micropython.org/viewtopic.php?t=4387#p25381](https://forum.micropython.org/viewtopic.php?t=4387#p25381)

## KiCad design Bike logger/pcb/pcb.kicad_pcb

Board: 2 copper layers, 90.2 x 48.3 mm, 108 parts (30 on the bottom side), 47 nets.

Parts:
C1, C2, C3, C6, C7, C8, C9, C10, C13, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26: 100nF; C_0402_1005Metric
C4, C11: 10uF; C_0603_1608Metric
C5, C14, C15, C16: 1uF; C_0603_1608Metric
C12: 10uF 100V; CP_Elec_6.3x7.7
D1, D2, D4, D5, D6, D7, D8, D9: BAT54S; SOT-23
D3: BAT54C; SOT-23
D10: LED; LED_0402_1005Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.7mm_M2.5_custom
J1: Micro_SD_Card; microSD_HC_Hirose_DM3AT-SF-PEJM5
J2, J8, J9: Conn_01x04; TerminalBlock_Phoenix_MKDS-1,5-4-5.08_1x04_P5.08mm_Horizont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
J3: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J4, J5, J6, J7: Conn_01x04; NS-Tech_Grove_1x04_P2mm_Vertical
Q1, Q2: MMBT5551L; SOT-23
R1, R2, R5, R6, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25: R; R_0402_1005Metric
R3, R4: 10k; R_0402_1005Metric
R7, R8, R9, R10, R11, R12, R13, R14: 4.7k; R_0402_1005Metric
SW1, SW2, SW4, SW4_reset1: SW_Push_1571563-4; SW_1571563-4
TP1, TP7, TP8, TP9, TP10, TP11, TP12, TP16, TP17, TP18, TP19, TP22, TP23, TP24, TP25, TP27, TP28, TP29, TP30, TP31, TP33, TP34: TestPoint; TestPoint_Pad_1.0x1.0mm
U1: ESP32-WROOM-32
U2: XC6210; SOT-23-5
U3: MS8607-02BA; LGA-8_3x5mm_P1.25mm
U4: LSM6DS3; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y
U5: CP2104; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
U6: XP_Power_STH; STH0548S3V3

Connections:
+3V3: C2.1, C4.2, C5.1, C16.2, C21.1, C22.1, C23.1, C24.1, C25.1, C26.2, D1.2, D2.2, D4.2, D5.2, D6.2, D7.2, D8.2, D9.2, J1.4, J2.3, J4.3, J5.3, J6.3, J7.3, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R23.2, U1.2, U2.5, U3.1, U4.5, U4.8, U5.5, U5.6, U5.7
+5V: C11.2, D3.1, J2.1, R24.2, TP1.1, U6.5
/DTR: Q1.2, R4.2, U5.23
/GPIO0: Q1.3, U1.25
/GPS_RX: J4.1, TP17.1, U1.28
/GPS_TX: J4.2, TP16.1, U1.27
/LED: D10.1, U1.12
/MISO: J1.7, TP9.1, U1.14
/MOSI: J1.3, TP10.1, U1.16
/Motor_A_adc: C7.1, D5.3, R17.2, R18.1, TP19.1, U1.7
/Motor_B_adc: C3.1, D4.3, R15.2, R16.1, TP18.1, U1.6
/Motor_pulse_A: J9.1, R17.1
/Motor_pulse_B: J9.2, R15.1
/PAS: J9.3, R5.1
/PAS_ADC: C6.1, D2.3, R5.2, R6.1, U1.4
/RESET: C20.1, Q2.3, R14.2, SW4_reset1.1, SW4_reset1.2, U1.3
/RTS: Q2.2, R3.2, U5.19
/RX0: TP29.1, U1.35, U5.20
/SCL1: J5.1, R8.2, TP25.1, U1.36, U3.8, U4.13
/SCL2: C13.1, D9.3, J6.1, R10.2, TP22.1, U1.30
/SDA1: J5.2, R7.2, TP24.1, U1.33, U3.7, U4.14
/SDA2: C10.1, D8.3, J6.2, R9.2, TP23.1, U1.31
/SPI_CLK: J1.5, TP11.1, U1.13
/SPI_SD_CS: J1.2, TP12.1, U1.23
/TX0: TP30.1, U1.34, U5.21
/Throttle: J9.4, R1.1
/button_down: C18.1, R12.2, SW2.1, SW2.2, U1.10
/button_select: C19.1, R13.2, SW4.1, SW4.2, U1.11
/button_up: C17.1, R11.2, SW1.1, SW1.2, U1.37
/misc_adc_1: C8.1, D6.3, R19.2, R20.1, TP27.1, U1.8
/misc_adc_2: C9.1, D7.3, R21.2, R22.1, TP28.1, U1.9
/misc_adc_raw_1: J7.2, R19.1
/misc_adc_raw_2: J7.1, R21.1
/throttle_ADC: C1.1, D1.3, R1.2, R2.1, U1.5
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.2, C14.1, C15.1, C16.1, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.1, D1.1, D2.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, H2.1, H4.1, J1.6, J1.11, J2.2, J2.4, J3.5, J3.6, J4.4, J5.4, J6.4, J7.4, J8.1, R2.2, R6.2, R16.2, R18.2, R20.2, R22.2, R25.2, SW1.3, SW1.4, SW2.3, SW2.4, SW4.3, SW4.4, SW4_reset1.3, SW4_reset1.4, U1.1, U1.15, U1.38, U2.2, U3.3, U4.6, U4.7, U5.2, U5.25, U6.7, U6.9
unnamed: C14.2, C15.2, D3.3, U2.1, U2.3
unnamed: D10.2, R23.1
unnamed: J3.2, TP33.1, U5.4
unnamed: J3.3, TP34.1, U5.3
unnamed: Q1.1, R3.1
unnamed: Q2.1, R4.1
unnamed: R24.1, R25.1, U6.6
unnamed: TP7.1, U1.24
unnamed: TP8.1, U1.26
unnamed: TP31.1, U1.29
VBATT: C12.2, J8.4, U6.1
VBUS: D3.2, J3.1, U5.8

## KiCad design Bike logger/pcb/current_voltage_sensor/current_voltage_sensor.kicad_pcb

Board: 2 copper layers, 29.2 x 16.5 mm, 11 parts (1 on the bottom side), 10 nets.

Parts:
J1: Conn_01x04; NS-Tech_Grove_1x04_P2mm_Vertical
J2, J3: Conn_01x01; TerminalBlock_TE_282834-2_1x02_P2.54mm_Horizontal
JP1, JP2: SolderJumper_3_Open; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm_NumberLabels
R1: 0.02 ohm; R_Shunt_Ohmite_LVK25
R2, R3: 2K; R_0402_1005Metric
TP1, TP2: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: LTC4151; DFN-10-1EP_3x3mm_P0.5mm_EP1.55x2.48mm

Connections:
+3V3: J1.3, R2.1, R3.1
/ADR0: JP1.2, U1.4
/ADR1: JP2.2, U1.3
/SCL: J1.1, R3.2, U1.6
/SDA: J1.2, R2.2, U1.7
/SENSE+: J3.1, JP1.1, JP2.1, R1.2, U1.1, U1.2
/SENSE-: J2.1, R1.1, U1.10
GND: J1.4, JP1.3, JP2.3, U1.9
unnamed: TP1.1, U1.8
unnamed: TP2.1, U1.5

## Code that names these connections

File Bike logger/Firmware/RTOS_sampling/config.h:

#ifdef __cplusplus
extern "C"
{
#endif

#ifndef Config_h
#define Config_h

/* ==================================================================== */
/* ========================== include files =========================== */
/* ==================================================================== */

/* Inclusion of system and local header files goes here */

/* ==================================================================== */
/* ============================ constants ============================= */
/* ==================================================================== */

/* #define and enum statements go here */

#define LED_BUILTIN 27
#define RXD2 17
#define TXD2 16

#define INA_226_I2C_ADDRESS 0x41

/* Config section */

/*
  Set to true or false to poll/not poll
*/
#define POLL_BARO (true)
#define POLL_GPS (true)
#define POLL_IMU (false)
#define POLL_INA226 (true)
#define POLL_BRAKE (false)
#define POLL_SPEED (false)

#define HEAP_ANALYSIS (false)
#define PERIODIC_CLOSE_FILE (true)
#define INTERVAL_BETWEEN_FLUSHING_FILE 10000UL

/* poll intervals in milliseconds */
#define INA226_SAMPLE_INTERVAL 10
#define GNSS_SAMPLE_INTERVAL 50
#define BARO_SAMPLE_INTERVAL 100
#define IMU_SAMPLE_INTERVAL 100
#define BLINK_INTERVAL 100
#define BRAKE_INTERVAL 100
#define SPEED_INTERVAL 100

#ifndef WIFI_CONFIG_H
#define YOUR_WIFI_SSID "YOUR_WIFI_SSID"
#define YOUR_WIFI_PASSWD "YOUR_WIFI_PASSWD"
#endif // !WIFI_CONFIG_H

#define MOTOR_PULSE_A_PIN 35
#define MOTOR_PULSE_B_PIN 34
#define PAS 36
#define THROTTLE 39

/* Number of GPS fixes in a second */
#define FIXS_PER_SECOND 4

/* INA226 info */
#define FULL_RANGE_VOLTAGE_DROP (float) 0.08192 // Volts
#define SHUNT_RESISTANCE (float)0.0024 // Ohms

/* I = V/R */
#define INA226_FULL_CURRENT_RANGE (float)(FULL_RANGE_VOLTAGE_DROP/SHUNT_RESISTANCE) // Amps

/* ==================================================================== */
/* ========================== public data ============================= */
/* ==================================================================== */

/* Definition of public (external) data types go here */

/* ==================================================================== */
/* ======================= public functions =========================== */
/* ==================================================================== */

/* Function prototypes for public (external) functions go here */

#endif
#ifdef __cplusplus
}
#endif

## Commit log (part)

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2021-04-19 use seperate function for init
2021-04-19 create function prototypes
2021-04-19 insert pulse counter rtos
2021-04-19 include pulse counter adc
2021-04-19 auto format only
2021-04-19 set correct pins for adc inputs PAS and brake
2021-04-19 scan negative edge
    It is normally high, to get the negative edge first
2021-04-19 turn off test pwm signal
2021-04-19 remove unused variables
2021-04-19 only measure positive edge of PAS sensor
    There is random triggering of the brake pin. So disable for now
2021-04-19 create function to write to sd with mutex
2021-04-19 remove legacy brake and speed check functions
2021-04-19 init mutexes earlier
2021-04-19 include import
2021-04-19 make separate file for heap analysis
2021-04-19 save to sd externally function
2021-04-19 save to sd
2021-04-19 set up #defines for polling brakes and speed
2021-04-19 import arduino functions
2021-04-19 put the adc reader in core 0, to free up core 1
2021-04-19 update #defines
2021-04-19 init all sensors before inititing mutexes.
    Or it seems to get stuck
2021-04-19 use defined format
2021-04-19 give higher priorities for logging edges
2021-04-19 update paths in gitignore
2021-04-19 process motor speed and pas
2021-04-27 filter out all zero pulse delays to prevent division errors
2021-04-27 give highest priority for adc reads
2021-04-27 display the important variables
2021-04-27 filter out the wierd motor speed values
2021-04-27 make xgboost predictions
2021-04-29 remove unused cell
2021-04-29 allow to work on plotly
2021-04-29 remove unused code
2021-04-30 create functions for low pass filtering
2021-04-30 calculate baro slope
2021-04-30 rename variables
2021-04-30 clean up md
2021-04-30 use constant sample rate, and do ml on slope vs power
2021-04-30 reinit the df_ml every time
2021-04-30 display filtered data over raw
2021-04-30 rearrange
2021-04-30 read data seperately
2021-04-30 show baro filter/not filtered overlay
2021-04-30 display predicted power
2021-05-01 do essential processing in one step
2021-05-01 get ml to work
2021-05-03 get multi display working
2021-05-03 remove unused plots
2021-05-03 reorder
2021-05-03 move filter function to seperate file
2021-05-03 remove phone data analysis
2021-05-03 update md
2021-05-03 reorder plots
2021-05-03 move energy_from_power_time() outside
2021-05-03 reorganise process function
2021-05-03 take raw data input
2021-05-03 simplify file read
2021-05-03 show prediction metrics in one line
2021-05-03 gen_ml_data in function
2021-05-03 atomise process functions
2021-05-03 filter motor speed
2021-05-03 add option to visualise data
2021-05-03 display predictions
2021-05-03 rename gps speed to remove [
2021-05-03 rename some params, and use multiple params for ML
2021-05-03 Reduce variable set
2021-05-04 update labels
2021-05-05 use nicer labels
2021-05-05 change accuracy metric
2021-05-05 put in some useful displays
2021-05-05 rename some output files
2021-05-05 display all variables
2021-05-05 Add in preliminary clustering algorithm
2021-05-05 force pullup the I2C address LSB pin, and SDx/SCx pins to save power
    Otherwise, it looks like the floating I2C address LSB pin is causing dataloss.
2021-05-05 use #defines for specifying adc min and max values
2021-05-05 add variables to the adc to voltage function
    So that we don't rely on globals
2021-05-05 remove unused line
2021-05-05 Just sample every 10 ms. NO fifo
2021-05-05 poll imu at 100 Hz
2021-05-05 poll imu by default
2021-05-05 don't serial print imu data
2021-05-06 add in plots showing brake noise
2021-05-06 ensure utc is timezone
2021-05-06 ensure all gnss fixes are OK
2021-05-06 add in imu data as features
2021-05-06 change train data to today's data
2021-05-06 use training data from today
2021-05-07 update texts
2021-05-07 auto format
2021-05-07 use single #define to poll brake and motor speed
2021-05-07 Use a struct to contain all the adc reader parameters
2021-05-07 remove unused functions
2021-05-07 uppercase all #defines
2021-05-07 add offset value to struct for each adc
2021-05-07 create second struct for brake
2021-05-07 pass offset value for adc
2021-05-07 remove unused comment
2021-05-07 don't initialise second brake reader
    It is causing all kinds of failures. Like these:
    ```
    E (275) I2S: /home/runner/work/esp32-arduino-lib-builder/esp32-arduino-lib-builder/esp-idf/components/driver/i2s.c:897 (i2s_param_config):I2S ADC built-in only support on I2S0
    E (276) I2S: I2S param configure error
    E (276) I2S: /home/runner/work/esp32-arduino-lib-builder/esp32-arduino-lib-builder/esp-idf/components/driver/i2s.c:1251 (i2s_adc_enable):Not initialized yet
    Guru Meditation Error: Core 0 panic'ed (LoadProhibited). Exception was unhandled.
2021-05-07 create a new page to read the state of line
2021-05-07 use older api
2021-05-07 use correct pointer
2021-05-07 make state logger work better with digital
2021-05-07 remove repeat definitions
2021-05-07 create #define to log state
2021-05-07 Revert "remove repeat definitions"
    This reverts commit 196865dab4c805e0bd502ea4917cce2fe32628f4.
2021-05-07 refactor Edge_detector_t to Digital_Edge_detector_t
2021-05-07 use floats to define dead zone
2021-05-07 redo range checks
2021-05-07 use thresholding
2021-05-07 revert accidental renames
2021-05-07 fix types
2021-05-07 create distinct name for process
2021-05-07 split motor speed and brake defines
2021-05-07 make edge detect to return which edge and log timestamp
2021-05-07 merge_asof forward
2021-05-08 include brake df
2021-05-08 clean up inputs for arguments
2021-05-08 display brake state
2021-05-10 revert back to old speed adc measurments
2021-05-10 just log on line state change.
2021-05-10 reject a bit more noise
    Done not fix the problem though. There is random noise on the line
2021-05-10 update brake state ever 10 milliseconds
2021-05-10 don't reset the GPS, it takes too long to get a fix.
2021-05-10 change dynamic model to portable and save config
    Maybe the portable version is more accurate?
2021-05-10 don't filter pulse_delay_us. It is loosing important information.
2021-05-10 suppress debug logs
2021-05-10 look at pulse delay closely
2021-05-11 use more robust datetime parser that rejects malformed timestamps
2021-05-11 parse safely the timestamp
2021-05-11 cleanup unused code
2021-05-11 cleanup
2021-05-12 works
2021-05-12 display variables on single plots
2021-05-12 filter out zero voltage
2021-05-12 remove unused comments
2021-05-12 create imu filter
2021-05-12 do less averaging
2021-05-12 show plot headers
2021-05-12 clean up displays
2021-05-12 set shunt resistance
2021-05-12 filter imu less
2021-05-12 ml params cleanup
2021-05-12 update plots
2021-05-13 display ina df only
2021-05-13 filter out voltages 0V
2021-05-13 use calibrated power
2021-05-13 update fps
2021-05-13 expand number of datasets
2021-05-13 use defined path
2021-05-13 remove unnessary defines
2021-05-13 combined all functions into single cell
2021-05-13 Combined all util functions
2021-05-14 move display plot functions to seperate file
2021-05-14 bin all variables in to longitude/latitude grid squares
2021-05-14 clean up imports
2021-05-14 group by location and time interval
2021-05-14 shorten stuff
2021-05-14 use function to do ml training
2021-05-15 add in binned view
2021-05-15 put in kalman filter
2021-05-15 put battery SocEstimater into a class
    Much cleaner and modular
2021-05-15 use the real battery module
2021-05-16 remove special battery.
2021-05-16 go back to using our old battery model
2021-05-17 Update constants for battery for the e-bike battery
2021-05-17 create a dataflow based on real data
2021-05-17 plots look ok
2021-05-17 create get_discharge_time()
2021-05-17 create class structure
2021-05-17 Discharge curve looks OK
2021-05-17 remove the charge stage requirement
2021-05-17 use Numpy array, not matrix.
2021-05-17 create abstracted data loading manager
2021-05-17 update matrix to array
2021-05-17 export data as consistent resampled data
2021-05-17 make predictions specific to putney loops
2021-05-17 resample ALL ml data to 10 milliseconds intervals
2021-05-17 load df from outside
2021-05-17 Revert "update matrix to array"
    This reverts commit de8646c560d81bcc90d5ed08f5b83840e562e861.
2021-05-17 rename main file
2021-05-17 rename folder Battery-Kalman to Battery_Kalman
2021-05-17 make kalman module importable as a module from outside
2021-05-17 add soc column
2021-05-17 add SOC as a feature
2021-05-17 log heading
2021-05-17 read imu data first
2021-05-17 read imu with high priority
    Otherwise, it seems like 0s are sent
2021-05-18 show progress of parsing
2021-05-18 don't us
2021-05-18 print progress
2021-05-18 use more efficient pandas based Coulomb counter
2021-05-18 dont bother with mapbox special token or MAPE
2021-05-18 add data paths
2021-05-18 make work
2021-05-18 Log accuracies of GPS fix
2021-05-18 serial printout the imu data
2021-05-18 add soc feature with specified method
2021-05-18 add method calculating SOC from ML[Incomplete]
2021-05-18 make soc calculator with ML
2021-05-18 Add GPS speed as Feature[IS it good??]
2021-05-18 make predictions work; Remove datetime from index
2021-05-18 add in new dataset
2021-05-18 atomise function
2021-05-18 remove GPS speed as a feature
2021-05-18 remove LSTM approach
2021-05-18 add SOC as seperate function
2021-05-19 move functions into right place
2021-05-19 rename file to non standard python variable
2021-05-19 make predictions work
2021-05-19 add function to do 3D plot
2021-05-19 remove all the resampling to be done do the mega dataframe
    If we resample to 10 milliseconds intervals, it will create rows for all the time we are not recording data at all, making the dataframe absolutely huge.
2021-05-19 get image regression approach to work
2021-05-20 works inaccurately
2021-05-20 fix issue with predictor image regressor
2021-05-20 remove repeated variables in combined df
2021-05-20 Parse new gps params recorded
2021-05-20 view correlations
2021-05-20 drop sensor column from merged df
2021-05-20 fixed bug where lots of rows were disappearing
2021-05-20 formating only
2021-05-20 fix index
2021-05-21 rename column
2021-05-21 show better pairplot
2021-05-21 make pair plot a function
2021-05-21 hover datetime
2021-05-21 more plots
2021-05-21 view vertical speed/distance
2021-05-21 add vertical distance as predictor
2021-05-21 re arrange
2021-05-21 select all the data
2021-05-22 make it train!
2021-05-22 remove subset of params
2021-05-22 append trip column and reduce memory
2021-05-22 organise functions
2021-05-22 split by trips
2021-05-22 save stuff
2021-05-24 display baro vs GPS
2021-05-24 hid all unused code cells
2021-05-24 create test of 15 minute runs
2021-05-24 don't calculate times that are absurd
2021-05-24 unhide all cells.
    ITs adding to too much diff noise on git
2021-05-24 plot scores for 10 minute trips
2021-05-24 higcut
2021-05-25 set capacity and cut off voltage.
2021-05-25 make it importable
2021-05-25 use GPS speed instead
2021-05-25 use nicer units
2021-05-25 show stats
2021-05-25 add in more data
2021-05-26 use df indexes
2021-05-27 move join plot and pair plot functions
2021-05-27 filter slope
2021-05-27 fix make_predictions_xgboost()
2021-05-27 add lightbgm
2021-05-27 standardise prediction metrics
2021-05-27 some formatting
2021-05-27 show pip instlal instructions for lightbgm
2021-05-27 use auto hyperparameter tuning
2021-05-28 use better coordinate converter
2021-05-29 cleanup the regressor params
2021-05-31 rename Temperature, Pressure, Humidity
2021-05-31 update the names of several more variables
2021-05-31 double quote to single quote
2021-05-31 update following variables
    gyro_x,y,z, Acceleration x,y,z, Brake state, motor_rpm, pas_rpm
2021-05-31 replace double quote
2021-05-31 stop duplicate trip ids
2021-06-04 uploaded meta data for auto generating tables in tgn
2021-06-07 submitted thesis
2021-06-08 Plot different test runs
2021-06-08 Get 3D plot working with filtered barometric altitude.
2021-06-08 fix scale of longitude/latitude on 3d plot
2021-06-25 prep for presentation
2021-06-28 use influxdb functionality
2021-06-30 put in grafana jsons
2021-07-01 update path
2021-07-02 Generate conda environment file
